# Keil uVision project Fire_LiteOS.uvprojx, settings and files
target Fire_LiteOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_LiteOS +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\Include;..\..\Libraries\FWlib\inc;..\..\LiteOS\arch\arm\arm-m\cortex-m3;..\..\LiteOS\arch\arm\arm-m\include;..\..\LiteOS\cmsis\1.0;..\..\LiteOS\cmsis\2.0;..\..\LiteOS\cmsis;..\..\LiteOS\kernel\include;..\..\LiteOS\kernel\base\include;..\..\LiteOS\kernel\extended\include;..\..\LiteOS\OS_CONFIG;..\..\User;..\..\User\led;..\..\User\Key;..\..\User\usart;..\..\User\beep;..\..\User\spi_flash;..\..\User\OLED;..\..\User\voice;..\..\User\NBIOT;..\..\User\wifi_net;..\..\User\adc
  asm include: ..\..\LiteOS\kernel\base\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/Key/: bsp_key.c
    ../../User/usart/: bsp_usart.c
    ../../User/beep/: bsp_beep.c
    ../../User/spi_flash/: bsp_spi_flash.c
    ../../User/OLED/: OLED_I2C.c codetab.h
    ../../User/voice/: XFS5152.C
    ../../User/wifi_net/: bsp_esp8266.c Common.c
    ../../User/adc/: bsp_adc.c
  group LiteOS/cmsis
    ../../LiteOS/cmsis/: cmsis_liteos.c
  group LiteOS/kernel
    ../../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memcheck.c los_membox.c los_memory.c
    ../../LiteOS/kernel/base/misc/: los_misc.c
    ../../LiteOS/kernel/base/om/: los_err.c
    ../../LiteOS/kernel/: los_init.c
    ../../LiteOS/kernel/base/mem/common/: los_memstat.c los_memstat.inc los_slab.c los_slabmem.c
  group LiteOS/arch
    ../../LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/config
    ../../LiteOS/OS_CONFIG/: target_config.h
  group DOC
    ../../Doc/: readme.txt
